<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Divisao_Assembly.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Primalidade_Assembly\Primalidade_Assembly.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Raiz_Assembly\Raiz_Assembly.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Resto_Div_Assembly\Resto_Div_Assembly.ewp</path>
    </project>
    <batchBuild />
</workspace>
