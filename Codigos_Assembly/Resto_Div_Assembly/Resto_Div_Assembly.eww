<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Resto_Div_Assembly.ewp</path>
    </project>
    <batchBuild />
</workspace>
