<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Primalidade_Assembly.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Raiz_Assembly\Raiz_Assembly.ewp</path>
    </project>
    <batchBuild />
</workspace>
